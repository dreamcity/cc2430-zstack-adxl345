<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AXD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>AXD</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>AXD</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>AXD</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>AXD</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>AXD</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>AXD</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


